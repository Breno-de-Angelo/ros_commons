Commit message: Refactor camera_link macro to allow proper definition of the link physics

File: urdf/domain.xacro (robot description, xacro)
@@ -429,5 +429,4 @@
     params="name"
   >
-    <link name="${name}"/>
     <link name="${name}_optical"/>
     <xacro:joint_fixed
